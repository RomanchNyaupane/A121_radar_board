# Keil uVision project STM32CubeMX.uvprojx, settings and files
target STM32CubeMX (6230000::V6.23::ARMCLANG)
  device: STM32WB55REVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x2002FFFF) IROM(0x08000000-0x807FFFF) IRAM2(0x20030000-0x200323FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32CubeMX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WB55xx
  c include: ../Inc;../Drivers/STM32WBxx_HAL_Driver/Inc;../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../Drivers/CMSIS/Include;C:\Users\roman.CAPNG\OneDrive\Desktop\Codebase\A121_config\acconeer_cortex_m4_armclang_a121-v1_12_0\cortex_m4_armclang\algorithms;C:\Users\roman.CAPNG\OneDrive\Desktop\Codebase\A121_config\acconeer_cortex_m4_armclang_a121-v1_12_0\cortex_m4_armclang\integration;C:\Users\roman.CAPNG\OneDrive\Desktop\Codebase\A121_config\acconeer_cortex_m4_armclang_a121-v1_12_0\cortex_m4_armclang\rss\include;C:\Users\roman.CAPNG\OneDrive\Desktop\Codebase\A121_config\acconeer_cortex_m4_armclang_a121-v1_12_0\cortex_m4_armclang\rss\lib;C:\Users\roman.CAPNG\OneDrive\Desktop\Codebase\A121_config\acconeer_cortex_m4_armclang_a121-v1_12_0\cortex_m4_armclang\examples\getting_started
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x2400
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User
    ../Src/: main.c stm32wbxx_it.c stm32wbxx_hal_msp.c
    C:/Users/roman.CAPNG/OneDrive/Desktop/Codebase/A121_config/acconeer_cortex_m4_armclang_a121-v1_12_0/cortex_m4_armclang/rss/lib/: libacc_detector_distance_a121.a libacconeer_a121.a
    C:/Users/roman.CAPNG/OneDrive/Desktop/Codebase/A121_config/acconeer_cortex_m4_armclang_a121-v1_12_0/cortex_m4_armclang/rss/include/: acc_config.h acc_config_subsweep.h acc_definitions.h acc_definitions_a121.h acc_definitions_common.h acc_detector_distance.h acc_detector_distance_definitions.h acc_hal_definitions_a121.h acc_processing.h acc_rss_a121.h acc_sensor.h acc_version.h
    C:/Users/roman.CAPNG/OneDrive/Desktop/Codebase/A121_config/acconeer_cortex_m4_armclang_a121-v1_12_0/cortex_m4_armclang/integration/: acc_hal_integration_a121.h acc_integration.h acc_integration_log.c acc_integration_log.h acc_integration_stm32.c acc_hal_integration_stm32cube_xe121_single_sensor.c
    C:/Users/roman.CAPNG/OneDrive/Desktop/Codebase/A121_config/acconeer_cortex_m4_armclang_a121-v1_12_0/cortex_m4_armclang/examples/getting_started/: example_detector_distance.c example_detector_distance.h
    C:/Users/roman.CAPNG/OneDrive/Desktop/Codebase/A121_config/acconeer_cortex_m4_armclang_a121-v1_12_0/cortex_m4_armclang/algorithms/: acc_alg_basic_utils.h acc_algorithm.c acc_algorithm.h
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_rcc.c stm32wbxx_ll_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
software components: CMSIS:CORE 6.1.1
